# Keil uVision project final.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: final +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 main.c oled.c util.c oled.h oledfont.h util.h
